# IAR project CC2530.ewp, settings and files
configuration srf05_cc2530 (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: chip=2530; xSECURITY_CCM
  ICC8051.CCDiagSuppress: Pa050,Pa084
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ../source/Components/utils; ../source/Components/common; ../source/Components/basicrf; ../source/Components/targets/interface; ../source/Components/assembly; ../source/Components/common/cc8051; ../source/Components/targets/srf05_soc; ../source/Components/radios/cc2530; ../source/Components/iic
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
  group application
    ../source/apps/: CC2530.c
  group basic rf
    ../source/Components/basicrf/: basic_rf.c basic_rf.h
  group hal/common
    ../source/Components/common/cc8051/: hal_cc8051.h
    ../source/Components/common/: hal_defs.h hal_int.c hal_types.h
  group hal/iic
    ../source/components/iic/: bh1750.c bh1750.h delay.c delay.h iic.c max44009.c max44009.h opt3001.c opt3001.h sht1x.c sht1x.h sht2x.c sht2x.h
    ../source/Components/iic/: iic.h
  group hal/interface
    ../source/Components/targets/interface/: hal_assert.h hal_button.h hal_digio.h hal_int.h hal_led.h hal_mcu.h
  group hal/rf
    ../source/Components/targets/interface/: hal_rf.h
  group hal/rf/cc2530
    ../source/Components/radios/cc2530/: clock.c clock.h hal_mcu.c hal_rf.c
    ../source/components/radios/cc2530/: hal_rf_security.c
  group hal/srf05_soc
    ../source/components/targets/srf05_soc/: C51_Gpio.c C51_Rtc.c
    ../source/Components/targets/srf05_soc/: hal_assert.c hal_board.c hal_board.h hal_button.c hal_digio.c hal_led.c
  group utilities
    ../source/Components/utils/: util.c util.h util_buffer.c util_buffer.h
